# Keil uVision project MusicKeyboard.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MusicKeyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\kayboard;.\HARDWARE\LED;.\SYSTEM\Delay;.\SYSTEM\music;.\SYSTEM\Timer;.\SYSTEM\51sys
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/kayboard/: keyboard.c keyboard.h
    ./HARDWARE/LED/: LED.c LED.h
  group SYSTEM
    ./SYSTEM/music/: music.h
    ./SYSTEM/Delay/: Delay.c Delay.h
    ./SYSTEM/Timer/: Timer0.c Timer0.h
